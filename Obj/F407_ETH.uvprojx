# Keil uVision project F407_ETH.uvprojx, settings and files
target F407_ETH (ARM-ADS)
  device: STM32F407ZETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: F407_ETH +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c misc: --C99
  c include: ..\Core;..\Lib\Inc;..\User\Inc;..\User;..\FreeRTOS\include;..\FreeRTOS\portable;..\lwip\src\include;..\lwip\system\OS;..\lwip\system;..\lwip\system\arch;..\NetDemo
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Core
    ../Core/: startup_stm32f407xx.s
  group Lib
    ../Lib/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_dma.c stm32f4xx_hal_gpio.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_pwr.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rtc.c stm32f4xx_hal_tim.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_eth.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_flash_ex.c
  group User
    ../User/Src/: gpio.c lwip.c main.c stm32f4xx_hal_msp.c stm32f4xx_it.c system_stm32f4xx.c usart.c
  group Lwip
    ../lwip/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../lwip/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../lwip/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../lwip/src/netif/: ethernet.c lowpan6.c slipif.c
  group Net
    ../lwip/system/arch/: lwipopts.h
    ../lwip/system/OS/: ethernetif.c sys_arch.c
  group FreeRTOS
    ../FreeRTOS/portable/: heap_4.c port.c
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group NetDemo
    ../NetDemo/: httpserver-netconn.c
